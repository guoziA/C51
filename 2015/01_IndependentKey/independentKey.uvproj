# Keil uVision project independentKey.uvproj, settings and files
target Target independentKey (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: independentKey +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group independentKey
    ./: IndependentKey.c test.c global.h global.c
