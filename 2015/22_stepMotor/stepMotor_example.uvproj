# Keil uVision project stepMotor_example.uvproj, settings and files
target example (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: stepMotor_example +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group example
    ./: stepMotor.c
