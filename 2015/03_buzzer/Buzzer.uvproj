# Keil uVision project Buzzer.uvproj, settings and files
target Target buzzer (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Buzzer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group buzzer
    ./: Buzzer.c
