# Keil uVision project exampleBuzzer.uvproj, settings and files
target Target exampleBuzzer (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: exampleBuzzer +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group exampleBuzzer
    ./: exampleBuzzer.c
