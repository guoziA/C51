# Keil uVision project LightCube1.uvproj, settings and files
target ligtCube1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: LightCube1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group test1
    ./: LightCube1.c scanNagative.c scan_layer.c constants.c
