# Keil uVision project smart_door.uvproj, settings and files
target Target sec (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: smart_door +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group sec
    ./: smartDoor.c
