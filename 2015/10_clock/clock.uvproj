# Keil uVision project clock.uvproj, settings and files
target Target c (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group c
    E:/My Documents/other/智控/: 红外遥控.c
