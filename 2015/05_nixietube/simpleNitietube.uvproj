# Keil uVision project simpleNitietube.uvproj, settings and files
target Target simple (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: simpleNitietube +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group simple
    ./: simple.c
