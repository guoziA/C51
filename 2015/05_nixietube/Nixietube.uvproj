# Keil uVision project Nixietube.uvproj, settings and files
target Target nixietube (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Nixietube +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group nixietube
    ./: Nixietube.c
