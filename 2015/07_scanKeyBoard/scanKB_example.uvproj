# Keil uVision project scanKB_example.uvproj, settings and files
target Target example (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: scanKB_example +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group example
    ./: sanKB_example.c
