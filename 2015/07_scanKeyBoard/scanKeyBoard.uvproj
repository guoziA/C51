# Keil uVision project scanKeyBoard.uvproj, settings and files
target Target scanKB (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: scanKeyBoard
  c flags: Optimize=8 SizeSpeed=1
  group Source Group scanKB
    ./: scanKB.c
