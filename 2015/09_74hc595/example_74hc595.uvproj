# Keil uVision project example_74hc595.uvproj, settings and files
target example_74hc595 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: example_74hc595 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group example
    ./: example_74hc595.c
