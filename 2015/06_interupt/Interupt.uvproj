# Keil uVision project Interupt.uvproj, settings and files
target Target interupt (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: Interupt +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group interupt
    ./: Interupt_.c
