# Keil uVision project drive51.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: drive51 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\drive
  group DRIVE
    ./drive/: drive.c drive_cfg.h drive_cpu.h drive_cpu.c driveincludes.h C51S.LIB
  group MAIN
    ./: MAIN.c
